* /home/joh/Devel/Arduino/Podregilo/KiCad/frontpanel.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Mi 27 Apr 2016 18:33:25 CEST

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
AFF1  ? ? ? ? Net-_AFF1-Pad5_ Net-_AFF1-Pad6_ Net-_AFF1-Pad7_ Net-_AFF1-Pad8_ Net-_AFF1-Pad9_ Net-_AFF1-Pad10_ Net-_AFF1-Pad11_ Net-_AFF1-Pad12_ ? Net-_AFF1-Pad14_ Net-_AFF1-Pad15_ Net-_AFF1-Pad16_ Net-_AFF1-Pad17_ ? Net-_AFF1-Pad19_ Net-_AFF1-Pad20_ Net-_AFF1-Pad21_ Net-_AFF1-Pad22_ Net-_AFF1-Pad22_ Net-_AFF1-Pad24_ Net-_AFF1-Pad25_ Net-_AFF1-Pad26_ Net-_AFF1-Pad27_ Net-_AFF1-Pad28_ Net-_AFF1-Pad29_ Net-_AFF1-Pad30_ Net-_AFF1-Pad22_ ? ? ? ? ? CA56-11EWA
JSW1  Net-_JSW1-Pad0_ Net-_AFF1-Pad22_ ? DIGITAST
JSW2  Net-_JSW2-Pad0_ Net-_AFF1-Pad22_ ? DIGITAST
P1  Net-_AFF1-Pad22_ Net-_AFF1-Pad22_ Net-_MSW1-Pad0_ Net-_MD4-Pad1_ Net-_MSW2-Pad0_ Net-_MD3-Pad1_ Net-_MSW3-Pad0_ Net-_MD2-Pad1_ Net-_MSW4-Pad0_ Net-_MD1-Pad1_ Net-_JSW1-Pad0_ Net-_LD1-Pad3_ Net-_JSW2-Pad0_ Net-_LD1-Pad1_ Net-_JSW3-Pad0_ Net-_LD2-Pad3_ Net-_JSW4-Pad0_ Net-_LD2-Pad1_ Net-_P1-Pad19_ Net-_LD3-Pad3_ Net-_CSW1-Pad0_ Net-_LD3-Pad1_ Net-_P1-Pad23_ Net-_LD4-Pad3_ Net-_LD1-Pad2_ Net-_LD4-Pad1_ CONN_02X13
P2  Net-_AFF1-Pad7_ Net-_AFF1-Pad26_ Net-_AFF1-Pad30_ Net-_AFF1-Pad27_ Net-_AFF1-Pad5_ Net-_AFF1-Pad10_ Net-_AFF1-Pad6_ Net-_AFF1-Pad11_ Net-_AFF1-Pad8_ Net-_AFF1-Pad12_ Net-_AFF1-Pad28_ Net-_AFF1-Pad24_ Net-_AFF1-Pad29_ Net-_AFF1-Pad25_ Net-_AFF1-Pad9_ Net-_AFF1-Pad16_ Net-_P2-Pad17_ Net-_AFF1-Pad21_ Net-_P2-Pad19_ Net-_AFF1-Pad14_ Net-_P2-Pad21_ Net-_AFF1-Pad15_ Net-_P2-Pad23_ Net-_AFF1-Pad17_ Net-_AFF1-Pad20_ Net-_AFF1-Pad19_ CONN_02X13
JSW3  Net-_JSW3-Pad0_ Net-_AFF1-Pad22_ ? DIGITAST
JSW4  Net-_JSW4-Pad0_ Net-_AFF1-Pad22_ ? DIGITAST
MSW1  Net-_MSW1-Pad0_ Net-_AFF1-Pad22_ ? DIGITAST
MSW2  Net-_MSW2-Pad0_ Net-_AFF1-Pad22_ ? DIGITAST
MSW3  Net-_MSW3-Pad0_ Net-_AFF1-Pad22_ ? DIGITAST
MSW4  Net-_MSW4-Pad0_ Net-_AFF1-Pad22_ ? DIGITAST
RSW1  Net-_P1-Pad19_ Net-_AFF1-Pad22_ ? DIGITAST
CSW1  Net-_CSW1-Pad0_ Net-_AFF1-Pad22_ ? DIGITAST
MD1  Net-_MD1-Pad1_ Net-_AFF1-Pad22_ LED
MD2  Net-_MD2-Pad1_ Net-_AFF1-Pad22_ LED
MD3  Net-_MD3-Pad1_ Net-_AFF1-Pad22_ LED
MD4  Net-_MD4-Pad1_ Net-_AFF1-Pad22_ LED
LD1  Net-_LD1-Pad1_ Net-_LD1-Pad2_ Net-_LD1-Pad3_ Led_x2
LD2  Net-_LD2-Pad1_ Net-_LD1-Pad2_ Net-_LD2-Pad3_ Led_x2
LD3  Net-_LD3-Pad1_ Net-_LD1-Pad2_ Net-_LD3-Pad3_ Led_x2
LD4  Net-_LD4-Pad1_ Net-_LD1-Pad2_ Net-_LD4-Pad3_ Led_x2
RD5  Net-_LD1-Pad2_ Net-_P2-Pad17_ LED
PD1  Net-_LD1-Pad2_ Net-_P2-Pad19_ LED
SD1  Net-_LD1-Pad2_ Net-_P2-Pad21_ LED
SD2  Net-_LD1-Pad2_ Net-_P2-Pad23_ LED
PSW1  Net-_P1-Pad23_ Net-_AFF1-Pad22_ ? DIGITAST

.end
